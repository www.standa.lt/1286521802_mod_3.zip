# Autodesk Inventor part: 8MT30-50internetui
## iProperties
Created: 2009-11
Part Number: 8MT30-50internetui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
